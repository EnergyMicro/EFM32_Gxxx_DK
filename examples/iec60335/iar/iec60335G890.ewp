# IAR project iec60335G890.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32G\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\iec60335_classb\lib\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: iec60335G890.bin
  ILINK.IlinkOutputFile: iec60335G890.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G890F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../: startup_efm32g_iar.s
    ../../../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../emlib/src/: em_cmu.c em_emu.c
  group Iec60335
    ../../../../../reptile/iec60335_classb/lib/src/: iec60335_class_b_timer_rtc_test.c iec60335_class_b_interrupt_test.c iec60335_class_b_flash_test.c iec60335_class_b_cpureg_test.c iec60335_class_b_programcounter_test.c iec60335_class_b_ram_test.c iec60335_class_b_post.c iec60335_class_b_cpureg_test_bist_iar.s iec60335_class_b_cpureg_test_post_iar.s
  group Source
    ../: main.c
