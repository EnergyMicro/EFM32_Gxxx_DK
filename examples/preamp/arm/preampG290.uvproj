# Keil uVision project preampG290.uvproj, settings and files
target preampG290 (ARM-ADS)
  device: EFM32G290F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: preampG290
  AfterMake: fromelf.exe --bin --output obj\preampG290.bin obj\preampG290.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G290F128 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/EnergyMicro/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../common/drivers/: dmactrl.c rtcdrv.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_dk_leds.c bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_adc.c em_cmu.c em_dac.c em_dma.c em_emu.c em_ebi.c em_gpio.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group Source
    ../: preamp.c
